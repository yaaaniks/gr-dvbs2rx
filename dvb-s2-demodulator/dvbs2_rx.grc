options:
  parameters:
    category: Custom
    description: Full DVB-S2 receiver. Processes IQ samples from stdin and outputs MPEG TS packets to stdout.
    generate_options: qt_gui
    id: dvbs2_rx
    output_language: python
    title: DVB-S2 Rx
  states: {}

blocks:
- name: Es
  id: variable
  parameters:
    value: '1'
  states: {}
- name: EsN0
  id: variable
  parameters:
    value: 10 ** (esn0_db / 10)
  states: {state: disabled}
- name: N0
  id: variable
  parameters:
    value: Es / EsN0
  states: {state: disabled}
- name: cl_order
  id: variable
  parameters:
    value: '4'
  states: {}
- name: code_rate
  id: variable
  parameters:
    value: modcod.upper().replace("8PSK", "").replace("QPSK", "")
  states: {}
- name: constellation
  id: variable
  parameters:
    value: modcod.replace(code_rate, "")
  states: {}
- name: costas_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tabs@2: 1, 1'
    label: 'Costas Loop BW '
    start: '0.0001'
    step: '0.0001'
    stop: '0.5'
    value: '0.0018'
  states: {}
- name: fir_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.35'
    gain: '1.0'
    ntaps: int(sps*20)
    samp_rate: float(samp_rate)
    sym_rate: float(sym_rate)
  states: {}
- name: freq
  id: variable
  parameters:
    value: '130000000'
  states: {}
- name: n_taps
  id: variable
  parameters:
    value: '25'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@2
    label: Noise
    start: '0'
    step: '0.0001'
    stop: '5'
    value: snr
  states: {}
- name: pilot_len
  id: variable
  parameters:
    value: int((360-1)/16)*36
  states: {}
- name: plframe_len
  id: variable
  parameters:
    value: '33282'
  states: {}
- name: plheader_len
  id: variable
  parameters:
    value: '90'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: qtgui_range_agc_setpoint
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@6
    label: AGC setpoint
    start: '-100'
    step: '1'
    stop: '100'
    value: '-90'
  states: {}
- name: qtgui_range_if_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@6
    label: IF Gain
    start: '20'
    step: '1'
    stop: '59'
    value: '40'
  states: {}
- name: qtgui_range_lna_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@6
    label: LNA gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '3'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: sym_rate * sps
  states: {}
- name: sym_sync_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tabs@2: 1, 0'
    label: SymSync Loop BW
    start: '0.0001'
    step: '0.0001'
    stop: '0.5'
    value: '0.003'
  states: {}
- name: variable_adaptive_algorithm
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: agc_gain
  id: parameter
  parameters:
    label: AGC gain
    type: eng_float
    value: '1'
  states: {}
- name: agc_rate
  id: parameter
  parameters:
    label: AGC update rate
    type: eng_float
    value: '0.2'
  states: {}
- name: agc_ref
  id: parameter
  parameters:
    label: AGC's reference value
    type: eng_float
    value: '1'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '0.01'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_1_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: '4096'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/semikozov/code/radio/dvb-s2-demodulator/demodulated.ts
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '100'
    max_iter: '400'
    scale: '0.01'
    type: float
    vlen: '4096'
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '20'
    type: float
  states: {}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: '20'
    type: float
  states: {}
- name: blocks_multiply_const_xx_0_1_0
  id: blocks_multiply_const_xx
  parameters:
    const: 0.000976562 / 4
    type: complex
    vlen: '4096'
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: '4096'
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_rms_xx_1
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_rms_xx_1_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '4096'
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/semikozov/code/radio/records/SDRuno_20240618_094736Z_1199989kHz.wav
    nchan: '2'
    repeat: 'False'
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0'
    seed: '0'
    taps: '1.0'
  states: {state: bypassed}
- name: debug
  id: parameter
  parameters:
    label: debugging level
    short_id: d
    type: intx
    value: '0'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: cl_order
    w: costas_loop_bw
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm
    num_taps: sym_rate
    sps: '10'
  states: {state: disabled}
- name: digital_symbol_sync_xx_1
  id: digital_symbol_sync_xx
  parameters:
    damping: sym_sync_damping
    loop_bw: sym_sync_loop_bw
    max_dev: '1.0'
    nfilters: rrc_nfilts
    osps: '1'
    pfb_mf_taps: firdes.root_raised_cosine(rrc_nfilts, samp_rate*rrc_nfilts, sym_rate, rolloff, (int(2*rrc_delay*sps) + 1)*rrc_nfilts)
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: dvbs2rx_agc_loop_xx_0
  id: dvbs2rx_agc_loop_xx
  parameters:
    hw_agc_if_gain: '1e-4'
    hw_agc_lna_state: '0.0'
    sw_agc_gain: '1.0'
    sw_agc_max_gain: '65536'
    sw_agc_rate: '1e-4'
    sw_agc_reference: '1.0'
    vlen: '4096'
  states: {}
- name: dvbs2rx_bbdeheader_bb_0
  id: dvbs2rx_bbdeheader_bb
  parameters:
    debug_level: debug
    framesize: frame_size
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dvbs2rx_bbdescrambler_bb_0
  id: dvbs2rx_bbdescrambler_bb
  parameters:
    framesize: frame_size
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dvbs2rx_bch_decoder_bb_0
  id: dvbs2rx_bch_decoder_bb
  parameters:
    debug_level: debug
    framesize: frame_size
    outputmode: OM_MESSAGE
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dvbs2rx_ldpc_decoder_bb_0
  id: dvbs2rx_ldpc_decoder_bb
  parameters:
    constellation: constellation
    debug_level: debug
    framesize: frame_size
    infomode: INFO_OFF
    max_trials: '25'
    outputmode: OM_MESSAGE
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dvbs2rx_plsync_cc_0
  id: dvbs2rx_plsync_cc
  parameters:
    acm_vcm: 'True'
    debug_level: '0'
    freq_est_period: '10'
    gold_code: '0'
    multistream: 'False'
    pls_filter_hi: '0xFFFFFFFFFFFFFFFF'
    pls_filter_lo: '0xFFFFFFFFFFFFFFFF'
    sps: sps
  states: {}
- name: dvbs2rx_xfecframe_demapper_cb_0
  id: dvbs2rx_xfecframe_demapper_cb
  parameters:
    constellation: constellation
    framesize: frame_size
    rate: code_rate
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nimport random\nimport collections\nimport struct\nimport itertools\nimport enum \nimport ctypes\n\nfrom itertools import cycle, islice\nfrom gnuradio import gr\n\nimport pmt\n\nclass UPID(enum.Enum):\n    TLM = np.byte(0x40)\n    DUMMY = np.byte(0x20)\n    FIRST_CHANNEL = np.byte(0x30)\n    SECOND_CHANNEL = np.byte(0x31)\n    \n\nSYM_RATE = 1000000 # mb used for tlm rate check\nFRAME_SIZE = 188\nSYNC = 0x47\nDUMMY_BYTE = np.byte(0xAA)\n\ndef consume(iterator, n):\n    \"Advance the iterator n-steps ahead. If n is none, consume entirely.\"\n    if n is None:\n        collections.deque(iterator, maxlen=0)\n    else:\n        next(islice(iterator, n, n), None)\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, fer_count=1000, debug_level = 0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='FER',   # will show up in GRC\n            in_sig=[np.byte],\n            out_sig=[np.float32]\n        )\n        self.message_port_register_out(pmt.intern('fer_counter'))\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.measurements = fer_count\n        self.debug_level = debug_level\n        \n        self.fer: float = 0\n        self.byte_err_cnt = 0\n        self.frame_count = 0\n        self.i_frame_count = 0\n        self.fer_cnt = 0\n        self.i_fer_cnt = 0\n        self.file = \"fer.log\"\n        self.byte_cnt = 0\n        self.least_dummy_cnts = {i.name: i.value for i in UPID}\n        self.most_dummy_cnts = {i.name: i.value for i in UPID} #dict(map(lambda item: (item.name, item.value), UPID))\n        \n        self.tlm_cnt = 0\n        \n        self.prev_frame_bytes = []\n        \n    \n    def find_frames(self, chunk: np.ndarray) -> list:\n        frames = []\n        if len(self.prev_frame_bytes):\n            lost = FRAME_SIZE - self.prev_frame_bytes.size\n            prev_frame = np.append(self.prev_frame_bytes, chunk[:lost])\n            frames.append(prev_frame)\n            self.prev_frame_bytes = []\n            chunk = chunk[lost:]\n        it = iter(enumerate(chunk))\n        temp_err = 0\n        for index, byte in it:\n            if byte != 0x47: \n                self.byte_err_cnt += 1\n                temp_err = self.byte_err_cnt // FRAME_SIZE \n                continue \n            if chunk.size - index < FRAME_SIZE:\n                self.prev_frame_bytes = chunk[index:]\n                break\n            \n            frame = chunk[index:index + FRAME_SIZE]\n            frames.append(frame)    \n            consume(it, FRAME_SIZE - 1)\n            self.fer_cnt += temp_err\n            temp_err = 0\n            self.byte_err_cnt = 0\n        return frames\n    \n    def check_header(self, header: list, upid: UPID) -> bool:\n        least_dummy_cnt = int(header[3] & 0b00001111)\n        most_dummy_cnt = int.from_bytes(header[4:8].tobytes(), 'big', signed=True)\n        uk_field = header[3] & 0b11110000\n        b = self.check_least_dummy_counter(least_dummy_cnt, upid) & \\\n            self.check_most_dummy_counter(most_dummy_cnt, upid) & \\\n            uk_field.bit_count() == 1\n        if uk_field.bit_count() != 1 and self.debug_level != 0:\n            print(f\"[FER]: Error in header for {upid.name}. Frame count: {self.i_frame_count}\\n\")\n        return b\n    \n    def check_correctness(self, frame: np.ndarray) -> None:\n        correct: bool = False\n        \n        if self.frame_count >= self.measurements:\n            self.fer = self.fer_cnt / self.measurements\n            self.fer_cnt = 0\n            self.frame_count = 0\n        if frame[2] in set(item.value for item in UPID):\n            upid = UPID(frame[2])\n            correct = self.check_header(frame[:8], upid) & self.check_payload(frame[8:].tolist(), upid)\n        if not correct:\n            self.i_fer_cnt += 1\n            self.fer_cnt += 1\n        self.i_frame_count += 1\n        self.frame_count += 1\n    \n    def check_least_dummy_counter(self, cnt: int, pid: UPID) -> bool:\n        if pid == UPID.TLM:\n            return True\n        b = (cnt - self.least_dummy_cnts[pid.name] == -15) or (cnt - self.least_dummy_cnts[pid.name] == 1) \n        if not b and self.debug_level != 0:\n            print(f\"[FER]: Error in least dummy counter for {pid.name}. Needed {self.least_dummy_cnts[pid.name] + 1}, it is {cnt}. Frame count: {self.i_frame_count}\\n\")\n        self.least_dummy_cnts[pid.name] = cnt\n        return b\n    \n    def check_most_dummy_counter(self, cnt: int, pid: UPID) -> bool:\n        if pid == UPID.TLM:\n            return True\n        b = (cnt - self.most_dummy_cnts[pid.name] == 1) or (cnt - self.most_dummy_cnts[pid.name] == 0)\n        if not b and self.debug_level != 0:\n             print(f\"[FER]: Error in most dummy counter for {pid.name}. Needed {self.most_dummy_cnts[pid.name] + 1}, it is {cnt}. Frame count: {self.i_frame_count}\\n\")        \n        self.most_dummy_cnts[pid.name] = cnt\n        return b\n    \n    def check_payload(self, payload: list, pid: UPID) -> bool:\n        if pid == UPID.DUMMY:\n            for byte in payload:\n                if byte != DUMMY_BYTE and self.debug_level != 0:\n                    print(f\"[FER]: Error in payload for {pid.name}. Needed {DUMMY_BYTE}, it is {byte}. Frame count: {self.i_frame_count}.\\n\")\n                    return False\n            return True\n        elif pid == UPID.FIRST_CHANNEL or pid == UPID.FIRST_CHANNEL:\n            for byte in payload:\n                if byte != 0x00 and self.debug_level != 0:\n                    print(f\"[FER]: Error in payload for {pid.name}. Needed {DUMMY_BYTE}, it is {byte}. Frame count: {self.i_frame_count}\\n\")\n                    return False\n            return True\n        else:\n            return True\n    \n    def work(self, input_items, output_items):\n        self.byte_cnt = self.nitems_read(0)\n        frames = self.find_frames(input_items[0])\n        for index, frame in enumerate(frames):\n            if frame[2] == UPID.TLM.value:\n                continue\n            self.check_correctness(frame)\n        output_items[0][:] = self.fer * 100\n        self.message_port_pub(pmt.intern('fer_counter'), pmt.intern(f'{self.i_fer_cnt}'))\n        return len(output_items[0])\n        \n"
    debug_level: '0'
    fer_count: '1000'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nimport random\nimport collections\nimport struct\nimport itertools\nimport enum \nimport ctypes\n\nfrom itertools import cycle, islice\nfrom gnuradio import gr\n\nimport pmt\n\nclass UPID(enum.Enum):\n    TLM = np.byte(0x40)\n    DUMMY = np.byte(0x20)\n    FIRST_CHANNEL = np.byte(0x30)\n    SECOND_CHANNEL = np.byte(0x31)\n    \n\nSYM_RATE = 1000000 # mb used for tlm rate check\nFRAME_SIZE = 188\nSYNC = 0x47\nDUMMY_BYTE = np.byte(0xAA)\n\ndef consume(iterator, n):\n    \"Advance the iterator n-steps ahead. If n is none, consume entirely.\"\n    if n is None:\n        collections.deque(iterator, maxlen=0)\n    else:\n        next(islice(iterator, n, n), None)\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, ber_count=100, debug_level = 0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='BER',   # will show up in GRC\n            in_sig=[np.byte],\n            out_sig=[np.float32]\n        )\n        self.message_port_register_out(pmt.intern('ber_counter'))\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.measurements = ber_count\n        self.debug_level = 0\n        \n        self.ber: float = 0\n        self.byte_err_cnt = 0\n        self.frame_count = 0\n        self.i_frame_count = 0\n        self.ber_cnt = 0\n        self.i_ber_cnt = 0\n        \n        self.least_dummy_cnts = {i: i.value for i in UPID}\n        self.most_dummy_cnts = {i: i.value for i in UPID} #dict(map(lambda item: (item.name, item.value), UPID))\n        \n        self.payload_checkers = {\n            UPID.TLM: self.check_tlm,\n            UPID.DUMMY: self.check_dummy,\n            UPID.FIRST_CHANNEL: self.check_first_channel,\n            UPID.SECOND_CHANNEL: self.check_second_channel\n        }\n        \n        self.tlm_cnt = 0\n        self.byte_counter = 0\n        self.prev_frame_bytes = []\n    \n    def check_tlm(self, payload: list):\n        pass\n        \n    def check_dummy(self, payload: list):\n        bit_error = 0\n        for byte in payload:\n            self.byte_counter += 1\n            if byte == DUMMY_BYTE:\n                continue\n            bit_error = abs((byte & DUMMY_BYTE).bit_count() - DUMMY_BYTE.bit_count()) + (byte & ~DUMMY_BYTE).bit_count() \n            if self.debug_level != 0:\n                print(f\"[BER]: Bit error {bit_error} in payload for dummy frame. Needed {DUMMY_BYTE}, it is {byte}. Frame count: {self.i_frame_count}\")\n            self.ber_cnt += bit_error\n            self.i_ber_cnt += bit_error\n        return bit_error == 0\n        \n    def check_first_channel(self, payload: list):\n        bit_error = 0\n        for byte in payload:\n            self.byte_counter += 1\n            if byte == 0x00:\n                continue\n            bit_error = (byte & 0xFF).bit_count() \n            if self.debug_level != 0:\n                print(f\"[BER]: Bit error {bit_error} in payload for first channel frame. Needed 0x00, it is {byte}. Frame count: {self.i_frame_count}\")\n            self.ber_cnt += bit_error\n            self.i_ber_cnt += bit_error\n        return bit_error == 0\n    \n    def check_second_channel(self, payload: list):\n        bit_error = 0\n        for byte in payload:\n            self.byte_counter += 1\n            if byte == 0x00:\n                continue\n            bit_error = (byte & 0xFF).bit_count()\n            if self.debug_level != 0:\n                print(f\"[BER]: Bit error {bit_error} in payload for second channel frame. Needed 0x00, it is {byte}. Frame count: {self.i_frame_count}\")\n            self.ber_cnt += bit_error\n            self.i_ber_cnt += bit_error\n        return bit_error == 0\n    \n    def find_frames(self, chunk: np.ndarray) -> list:\n        frames = []\n        if len(self.prev_frame_bytes):\n            lost = FRAME_SIZE - self.prev_frame_bytes.size\n            prev_frame = np.append(self.prev_frame_bytes, chunk[:lost])\n            frames.append(prev_frame)\n            self.prev_frame_bytes = []\n            chunk = chunk[lost:]\n        it = iter(enumerate(chunk))\n        temp_err = 0\n        for index, byte in it:\n            if byte != SYNC:\n                self.byte_counter += 1\n                continue \n            if chunk.size - index < FRAME_SIZE:\n                self.prev_frame_bytes = chunk[index:]\n                break\n            \n            frame = chunk[index:index + FRAME_SIZE]\n            frames.append(frame)    \n            consume(it, FRAME_SIZE - 1)\n            \n            self.ber_cnt += self.byte_err_cnt\n            self.i_ber_cnt += self.byte_err_cnt\n            self.byte_err_cnt = 0\n        return frames\n    \n    def check_header(self, header: list, upid: UPID) -> None:\n        least_dummy_cnt = int(header[3] & 0b00001111)\n        most_dummy_cnt = int.from_bytes(header[4:8].tobytes(), 'big', signed=True)\n        \n        uk_field = header[3] & 0b11110000\n        \n        self.check_least_dummy_counter(least_dummy_cnt, upid)\n        self.check_most_dummy_counter(most_dummy_cnt, upid)\n        self.byte_counter += 8\n        if uk_field.bit_count() != 1 and self.debug_level != 0:\n             print(f\"[BER]: Error in header for {upid.name}. Frame count: {self.i_frame_count}\")\n    \n    def check_correctness(self, frame: np.ndarray) -> None:\n        if self.frame_count > self.measurements:\n            self.frame_count = 0\n            self.ber = self.ber_cnt / (self.measurements * FRAME_SIZE * 8) \n            #print(f\"Current BER = {self.ber}\")  \n            self.ber_cnt = 0\n        if frame[2] in set(item.value for item in UPID):\n            upid = UPID(frame[2])\n            checker = self.payload_checkers[upid]\n            self.check_header(frame[:8], upid)\n            checker(frame[8:].tolist())\n        else:\n            self.ber_cnt += FRAME_SIZE * 8\n            self.i_ber_cnt += FRAME_SIZE * 8\n        self.i_frame_count += 1\n        self.frame_count += 1\n    \n    def check_least_dummy_counter(self, cnt: int, pid: UPID) -> bool:\n        if pid == UPID.TLM:\n            return True\n        expected_cnt = self.least_dummy_cnts[pid] + 1\n        if expected_cnt > 15:\n            expected_cnt = 0\n        bit_error = abs((cnt & expected_cnt).bit_count() - expected_cnt.bit_count()) + (cnt & ~expected_cnt).bit_count() \n        self.least_dummy_cnts[pid] = cnt\n        self.ber_cnt += bit_error\n        self.i_ber_cnt += bit_error\n        if bit_error != 0 and self.debug_level != 0:\n            print(f\"[BER]: Bit error {bit_error} in least dummy counter for {pid.name}. Needed {expected_cnt}, it is {cnt}. Frame count: {self.i_frame_count}\")\n        return bit_error == 0\n    \n    def check_most_dummy_counter(self, cnt: int, pid: UPID) -> bool:\n        if pid == UPID.TLM:\n            return True\n        if self.most_dummy_cnts[pid] == 0 and cnt == 0:\n            return True\n        expected_cnt = self.most_dummy_cnts[pid] + 1\n        bit_error = abs((cnt & expected_cnt).bit_count() - expected_cnt.bit_count()) + (cnt & ~expected_cnt).bit_count() \n        self.most_dummy_cnts[pid] = cnt\n        self.ber_cnt += bit_error\n        self.i_ber_cnt += bit_error\n        if bit_error != 0 and self.debug_level != 0:\n            print(f\"[BER]: Bit error {bit_error} in most dummy counter for {pid.name}. Needed {expected_cnt}, it is {cnt}.  Frame count: {self.i_frame_count}\")\n        return bit_error == 0\n    \n    def work(self, input_items, output_items):\n        self.byte_cnt = self.nitems_read(0)\n        frames = self.find_frames(input_items[0])\n        for index, frame in enumerate(frames):\n            if frame[2] == UPID.TLM.value:\n                continue\n            self.check_correctness(frame)\n        output_items[0][:] = self.ber * 100\n        self.message_port_pub(pmt.intern('ber_counter'), pmt.intern(f'{self.i_ber_cnt}'))\n        return len(output_items[0])\n        \n\n"
    ber_count: '1000'
    debug_level: '0'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '4096'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(4096)
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: fir_taps
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: fir_taps
    type: ccc
  states: {}
- name: fir_filter_xxx_0_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: fir_taps
    type: ccc
  states: {}
- name: frame_size
  id: parameter
  parameters:
    label: FECFRAME size
    short_id: f
    type: str
    value: normal
  states: {}
- name: gold_code
  id: parameter
  parameters:
    label: Gold code
    type: intx
    value: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: modcod
  id: parameter
  parameters:
    label: MODCOD
    short_id: m
    type: str
    value: QPSK1/2
  states: {}
- name: pl_freq_est_period
  id: parameter
  parameters:
    label: PL synchronizer's frequency estimation period in frames
    type: intx
    value: '10'
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'tabs@2: 0,1 '
    legend: 'False'
    name: '"PL Framer Output"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'tabs@2: 0, 0'
    legend: 'False'
    name: '"Symbol Sync Output"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'tabs@2: 0,1'
    legend: 'False'
    name: '"PL Framer Output"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: tabs@5
    is_pair: 'False'
    label: Current bit errors
    type: string
  states: {}
- name: qtgui_edit_box_msg_1
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: tabs@5
    is_pair: 'False'
    label: Current frame errors
    type: string
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: tabs@4
    label1: Im
    label2: Re
    samp_per_symbol: '10'
    size: '1024'
    srate: samp_rate
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: tabs@1
    label1: Before
    name: '"Frequency"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: tabs@2
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: tabs@6
    type: complex
    ymax: '-30'
    ymin: '-80'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: tabs@0:0,3,1,1
    name: '"RMS Level"'
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: tabs@5
    label1: FER
    label2: BER
    max: '100'
    min: '0'
    name: '"Packet error rate (%)"'
    nconnections: '2'
    type: float
    update_time: '0.001'
  states: {}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '100'
    min: '-100'
    name: '"SNR"'
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: tabs@3
    label1: I
    label2: Q
    size: plframe_len - pilot_len - plheader_len
    srate: samp_rate
    type: complex
    ylabel: PLFRAME Symbols
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: '4096'
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@0:0,0,1,3
    name: '"Spectrogram"'
    type: complex
  states: {}
- name: rolloff
  id: parameter
  parameters:
    label: rolloff factor
    short_id: r
    type: eng_float
    value: '0.2'
  states: {}
- name: rrc_delay
  id: parameter
  parameters:
    label: RRC filter delay in symbol periods
    type: intx
    value: '25'
  states: {}
- name: rrc_nfilts
  id: parameter
  parameters:
    label: number of branches on the polyphase RRC filter
    type: intx
    value: '128'
  states: {}
- name: sdrplay3_rsp1_0
  id: sdrplay3_rsp1
  parameters:
    AGC: 'False'
    agc_set_point: '-30'
    bandwidth: 8000e3
    center_freq: freq
    dc_offset_mode: 'True'
    debug_mode: 'True'
    driver: '0'
    freq_corr: '0'
    if_gRdB: qtgui_range_if_gain
    iq_balance_mode: 'True'
    output_type: fc32
    rf_gRLNA: qtgui_range_lna_gain
    rf_gR_mode: LNA
    rf_gRdB: qtgui_range_lna_gain
    rsp_selector: ''
    sample_rate: samp_rate
    sample_sequence_gaps_check: 'True'
    show_gain_changes: 'True'
  states: {}
- name: snr
  id: parameter
  parameters:
    label: starting SNR in dB
    type: eng_float
    value: '1.2'
  states: {}
- name: sps
  id: parameter
  parameters:
    label: oversampling ratio in samples per symbol
    short_id: o
    type: eng_float
    value: '5'
  states: {}
- name: sym_rate
  id: parameter
  parameters:
    label: symbol rate in bauds
    short_id: s
    type: intx
    value: '2000000'
  states: {}
- name: sym_sync_damping
  id: parameter
  parameters:
    label: symbol synchronizer's damping factor
    type: eng_float
    value: '1.6'
  states: {}
- name: sym_sync_loop_bw
  id: parameter
  parameters:
    label: symbol synchronizer's loop bandwidth
    type: eng_float
    value: '0.0045'
  states: {state: disabled}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0
    label0: Waterfall
    label1: Frequency Correction
    label2: Synchronization
    label3: Frame Recovery
    label4: Eye Diagrams
    label5: Error Rate
    label6: Input SIgnal
    label7: Test
    num_tabs: '8'
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    comment: Noise-added input signal
    stream_id: noisy
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: out_bytes
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: framer_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: out_bytes
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: noisy
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: framer_out
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_add_xx_0, '0']
- [analog_agc_xx_0, '0', fir_filter_xxx_0_0, '0']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_1, '0']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_1_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0, '0', fir_filter_xxx_0_1, '0']
- [analog_noise_source_x_0, '0', qtgui_freq_sink_x_1, '1']
- [blocks_add_xx_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_add_xx_0, '0', virtual_sink_1, '0']
- [blocks_complex_to_mag_squared_1_0, '0', blocks_nlog10_ff_1, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_moving_average_xx_0, '0', dvbs2rx_agc_loop_xx_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_sub_xx_0, '1']
- [blocks_multiply_const_xx_0_0, '0', blocks_sub_xx_0, '0']
- [blocks_multiply_const_xx_0_1_0, '0', blocks_complex_to_mag_squared_1_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_nlog10_ff_0_0, '0', blocks_multiply_const_xx_0_0, '0']
- [blocks_nlog10_ff_1, '0', blocks_moving_average_xx_0, '0']
- [blocks_rms_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_rms_xx_1, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_rms_xx_1_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_stream_to_vector_1, '0', fft_vxx_0, '0']
- [blocks_sub_xx_0, '0', qtgui_number_sink_2, '0']
- [blocks_throttle2_0, '0', analog_agc_xx_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [channels_channel_model_0, '0', digital_symbol_sync_xx_1, '0']
- [digital_costas_loop_cc_0, '0', digital_linear_equalizer_0, '0']
- [digital_costas_loop_cc_0, '0', dvbs2rx_plsync_cc_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_1_1, '0']
- [digital_costas_loop_cc_0, '0', qtgui_eye_sink_x_0, '0']
- [digital_symbol_sync_xx_1, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_1, '0', qtgui_const_sink_x_1_0, '0']
- [dvbs2rx_agc_loop_xx_0, gain_cmd, sdrplay3_rsp1_0, cmd]
- [dvbs2rx_bbdeheader_bb_0, '0', virtual_sink_3, '0']
- [dvbs2rx_bbdescrambler_bb_0, '0', dvbs2rx_bbdeheader_bb_0, '0']
- [dvbs2rx_bch_decoder_bb_0, '0', dvbs2rx_bbdescrambler_bb_0, '0']
- [dvbs2rx_ldpc_decoder_bb_0, '0', dvbs2rx_bch_decoder_bb_0, '0']
- [dvbs2rx_ldpc_decoder_bb_0, llr_pdu, dvbs2rx_xfecframe_demapper_cb_0, llr_pdu]
- [dvbs2rx_plsync_cc_0, '0', qtgui_const_sink_x_1, '0']
- [dvbs2rx_plsync_cc_0, '0', qtgui_time_sink_x_1, '0']
- [dvbs2rx_plsync_cc_0, '0', virtual_sink_4, '0']
- [dvbs2rx_xfecframe_demapper_cb_0, '0', dvbs2rx_ldpc_decoder_bb_0, '0']
- [epy_block_0, '0', qtgui_number_sink_1, '0']
- [epy_block_0, fer_counter, qtgui_edit_box_msg_1, val]
- [epy_block_1, '0', qtgui_number_sink_1, '1']
- [epy_block_1, ber_counter, qtgui_edit_box_msg_0, val]
- [fft_vxx_0, '0', blocks_multiply_const_xx_0_1_0, '0']
- [fir_filter_xxx_0, '0', channels_channel_model_0, '0']
- [fir_filter_xxx_0_0, '0', blocks_rms_xx_1, '0']
- [fir_filter_xxx_0_1, '0', blocks_rms_xx_1_0, '0']
- [sdrplay3_rsp1_0, '0', analog_agc_xx_0, '0']
- [sdrplay3_rsp1_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_0, '0', blocks_file_sink_0, '0']
- [virtual_source_0, '0', epy_block_0, '0']
- [virtual_source_0, '0', epy_block_1, '0']
- [virtual_source_2, '0', blocks_rms_xx_0, '0']
- [virtual_source_2, '0', fir_filter_xxx_0, '0']
- [virtual_source_2, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_3, '0', dvbs2rx_xfecframe_demapper_cb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
