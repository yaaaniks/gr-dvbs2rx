options:
  parameters:
    author: Semikozov Ian
    generate_options: no_gui
    id: ground_station
    output_language: python
    title: Ground Station Release
  states: {}

blocks:
- name: cl_order
  id: variable
  parameters:
    value: '4'
  states: {}
- name: code_rate
  id: variable
  parameters:
    value: modcod.upper().replace("8PSK", "").replace("QPSK", "")
  states: {}
- name: constellation
  id: variable
  parameters:
    value: modcod.replace(code_rate, "")
  states: {}
- name: fir_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.35'
    gain: '1.0'
    ntaps: int(sps*n_taps)
    samp_rate: float(samp_rate)
    sym_rate: float(sym_rate)
  states: {}
- name: freq
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: n_taps
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: sps*sym_rate
  states: {}
- name: agc_gain
  id: parameter
  parameters:
    label: AGC gain
    type: eng_float
    value: '1'
  states: {}
- name: agc_rate
  id: parameter
  parameters:
    label: AGC update rate
    type: eng_float
    value: '0.2'
  states: {}
- name: agc_ref
  id: parameter
  parameters:
    label: AGC's reference value
    type: eng_float
    value: '1'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: agc_rate
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/semikozov/example.ts
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0'
    seed: '0'
    taps: '1.0'
  states: {state: bypassed}
- name: costas_loop_bw
  id: parameter
  parameters:
    label: Costas Loop Bandwidth
    short_id: c
    type: eng_float
    value: '0.0018'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: cl_order
    w: costas_loop_bw
  states: {}
- name: digital_symbol_sync_xx_1
  id: digital_symbol_sync_xx
  parameters:
    damping: sym_sync_damping
    loop_bw: sym_sync_loop_bw
    max_dev: '1.0'
    nfilters: polyphase_filterbanks
    osps: '1'
    pfb_mf_taps: firdes.root_raised_cosine(rrc_nfilts, samp_rate*rrc_nfilts, sym_rate, rolloff, (int(2*rrc_delay*sps) + 1)*rrc_nfilts)
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: dvbs2rx_bbdeheader_bb_0
  id: dvbs2rx_bbdeheader_bb
  parameters:
    debug_level: '0'
    framesize: frame_size
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dvbs2rx_bbdescrambler_bb_0
  id: dvbs2rx_bbdescrambler_bb
  parameters:
    framesize: frame_size
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dvbs2rx_bch_decoder_bb_0
  id: dvbs2rx_bch_decoder_bb
  parameters:
    debug_level: '0'
    framesize: frame_size
    outputmode: OM_MESSAGE
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dvbs2rx_ldpc_decoder_bb_0
  id: dvbs2rx_ldpc_decoder_bb
  parameters:
    constellation: constellation
    debug_level: '0'
    framesize: frame_size
    infomode: INFO_OFF
    max_trials: '25'
    outputmode: OM_MESSAGE
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dvbs2rx_plframer_cc_0
  id: dvbs2rx_plframer_cc
  parameters:
    debug_level: '0'
    freq_est_period: pl_freq_est_period
    gold_code: '0'
    pls_code: '5'
    sps: sps
  states: {}
- name: dvbs2rx_xfecframe_demapper_cb_0
  id: dvbs2rx_xfecframe_demapper_cb
  parameters:
    constellation: constellation
    framesize: frame_size
    rate: code_rate
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: fir_taps
    type: ccc
  states: {}
- name: frame_size
  id: parameter
  parameters:
    label: FECFRAME size
    short_id: f
    type: str
    value: normal
  states: {}
- name: gold_code
  id: parameter
  parameters:
    label: Gold code
    type: intx
    value: '1'
  states: {}
- name: modcod
  id: parameter
  parameters:
    label: MODCOD
    short_id: m
    type: str
    value: QPSK1/2
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"driver=miri"'
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: pl_freq_est_period
  id: parameter
  parameters:
    label: PL synchronizer's frequency estimation period in frames
    type: intx
    value: '10'
  states: {}
- name: polyphase_filterbanks
  id: parameter
  parameters:
    label: Count of polyphase filter banks
    short_id: b
    type: intx
    value: '128'
  states: {}
- name: rolloff
  id: parameter
  parameters:
    label: rolloff factor
    short_id: r
    type: eng_float
    value: '0.2'
  states: {}
- name: rrc_delay
  id: parameter
  parameters:
    label: RRC filter delay in symbol periods
    type: intx
    value: '25'
  states: {}
- name: rrc_nfilts
  id: parameter
  parameters:
    label: number of branches on the polyphase RRC filter
    type: intx
    value: '128'
  states: {}
- name: sdrplay3_rsp1_0
  id: sdrplay3_rsp1
  parameters:
    AGC: 'False'
    agc_set_point: '-30'
    bandwidth: '0'
    center_freq: '0'
    dc_offset_mode: 'False'
    debug_mode: 'False'
    driver: '0'
    freq_corr: '0'
    if_gRdB: '40'
    iq_balance_mode: 'False'
    output_type: fc32
    rf_gRLNA: '0'
    rf_gR_mode: dB
    rf_gRdB: '0'
    rsp_selector: ''
    sample_rate: samp_rate
    sample_sequence_gaps_check: 'False'
    show_gain_changes: 'False'
  states: {}
- name: sps
  id: parameter
  parameters:
    label: oversampling ratio in samples per symbol
    short_id: o
    type: eng_float
    value: '5'
  states: {}
- name: sym_rate
  id: parameter
  parameters:
    label: symbol rate in bauds
    short_id: s
    type: intx
    value: '2000000'
  states: {}
- name: sym_sync_damping
  id: parameter
  parameters:
    label: symbol synchronizer's damping factor
    type: eng_float
    value: '1.6'
  states: {}
- name: sym_sync_loop_bw
  id: parameter
  parameters:
    label: 'Symbol Synchronizer Loop BandWidth '
    type: eng_float
    value: '0.003'
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: out
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: synchronized
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: out
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: synchronized
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_rms_xx_0, '0']
- [analog_agc_xx_0, '0', fir_filter_xxx_0, '0']
- [blocks_rms_xx_0, '0', blocks_null_sink_0, '0']
- [channels_channel_model_0, '0', digital_symbol_sync_xx_1, '0']
- [digital_costas_loop_cc_0, '0', dvbs2rx_plframer_cc_0, '0']
- [digital_symbol_sync_xx_1, '0', digital_costas_loop_cc_0, '0']
- [dvbs2rx_bbdeheader_bb_0, '0', virtual_sink_3, '0']
- [dvbs2rx_bbdescrambler_bb_0, '0', dvbs2rx_bbdeheader_bb_0, '0']
- [dvbs2rx_bch_decoder_bb_0, '0', dvbs2rx_bbdescrambler_bb_0, '0']
- [dvbs2rx_ldpc_decoder_bb_0, '0', dvbs2rx_bch_decoder_bb_0, '0']
- [dvbs2rx_ldpc_decoder_bb_0, llr_pdu, dvbs2rx_xfecframe_demapper_cb_0, llr_pdu]
- [dvbs2rx_plframer_cc_0, '0', virtual_sink_4, '0']
- [dvbs2rx_xfecframe_demapper_cb_0, '0', dvbs2rx_ldpc_decoder_bb_0, '0']
- [fir_filter_xxx_0, '0', channels_channel_model_0, '0']
- [osmosdr_source_0, '0', analog_agc_xx_0, '0']
- [sdrplay3_rsp1_0, '0', analog_agc_xx_0, '0']
- [virtual_source_0, '0', blocks_file_sink_0, '0']
- [virtual_source_3, '0', dvbs2rx_xfecframe_demapper_cb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
