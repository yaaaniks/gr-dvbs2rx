options:
  parameters:
    category: '[Core]/Digital Television/DVB-S2'
    description: DVB-S2 Rx
    generate_options: hb
    id: dvbs2rx_rx_hier
    output_language: python
    title: DVB-S2 Rx Hierarchical Block
  states: {}

blocks:
- name: code_rate
  id: variable
  parameters:
    value: modcod.upper().replace("8PSK", "").replace("QPSK", "")
  states: {}
- name: constellation
  id: variable
  parameters:
    value: modcod.replace(code_rate, "")
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: sym_rate * sps
  states: {}
- name: agc_gain
  id: parameter
  parameters:
    label: AGC gain
    type: eng_float
    value: '1'
  states: {}
- name: agc_rate
  id: parameter
  parameters:
    label: AGC update rate
    type: eng_float
    value: '1e-5'
  states: {}
- name: agc_ref
  id: parameter
  parameters:
    label: AGC reference
    type: eng_float
    value: '1'
  states: {}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: agc_gain
    max_gain: '65536'
    rate: agc_rate
    reference: agc_ref
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: debug
  id: parameter
  parameters:
    label: Debugging Level
    type: intx
    value: '100'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: sym_sync_loop_bw
  states: {}
- name: digital_symbol_sync_xx_1
  id: digital_symbol_sync_xx
  parameters:
    damping: sym_sync_damping
    loop_bw: sym_sync_loop_bw
    max_dev: '1.5'
    nfilters: rrc_nfilts
    osps: '1'
    pfb_mf_taps: firdes.root_raised_cosine(rrc_nfilts, samp_rate*rrc_nfilts, sym_rate, rolloff, (int(2*rrc_delay*sps) + 1)*rrc_nfilts)
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: dvbs2rx_bbdeheader_bb_0
  id: dvbs2rx_bbdeheader_bb
  parameters:
    debug_level: debug
    framesize: frame_size
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dvbs2rx_bbdescrambler_bb_0
  id: dvbs2rx_bbdescrambler_bb
  parameters:
    framesize: frame_size
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dvbs2rx_bch_decoder_bb_0
  id: dvbs2rx_bch_decoder_bb
  parameters:
    debug_level: debug
    framesize: frame_size
    outputmode: OM_MESSAGE
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dvbs2rx_ldpc_decoder_bb_0
  id: dvbs2rx_ldpc_decoder_bb
  parameters:
    constellation: constellation
    debug_level: debug
    framesize: frame_size
    infomode: INFO_OFF
    max_trials: '25'
    outputmode: OM_MESSAGE
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dvbs2rx_plsync_cc_0_0
  id: dvbs2rx_plsync_cc
  parameters:
    acm_vcm: 'True'
    debug_level: debug
    freq_est_period: '10'
    gold_code: '0'
    multistream: 'False'
    pls_filter_hi: '0xFFFFFFFFFFFFFFFF'
    pls_filter_lo: '0xFFFFFFFFFFFFFFFF'
    sps: sps
  states: {}
- name: dvbs2rx_rotator_cc_foffset_corr
  id: dvbs2rx_rotator_cc
  parameters:
    comment: Frequency Correction Block
    phase_inc: '0'
    tag_inc_update: 'True'
  states: {state: disabled}
- name: dvbs2rx_xfecframe_demapper_cb_0
  id: dvbs2rx_xfecframe_demapper_cb
  parameters:
    constellation: constellation
    framesize: frame_size
    rate: code_rate
  states: {}
- name: frame_size
  id: parameter
  parameters:
    label: FECFRAME size
    type: str
    value: normal
  states: {}
- name: gold_code
  id: parameter
  parameters:
    label: Gold code
    type: intx
    value: '0'
  states: {}
- name: modcod
  id: parameter
  parameters:
    label: MODCOD
    type: str
    value: QPSK1/4
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: sym_sync_out
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_1_0
  id: pad_sink
  parameters:
    label: pl_sync_out
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: rotator_out
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_2_0
  id: pad_sink
  parameters:
    label: agc_out
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pl_freq_est_period
  id: parameter
  parameters:
    label: PL Freq. Corr. Period
    type: intx
    value: '20'
  states: {}
- name: rolloff
  id: parameter
  parameters:
    label: Rolloff factor
    type: eng_float
    value: '0.2'
  states: {}
- name: rrc_delay
  id: parameter
  parameters:
    label: RRC filter delay
    type: intx
    value: '25'
  states: {}
- name: rrc_nfilts
  id: parameter
  parameters:
    label: Polyphase RRC branches
    type: intx
    value: '128'
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Oversampling ratio
    type: eng_float
    value: '2'
  states: {}
- name: sym_rate
  id: parameter
  parameters:
    label: Symbol rate
    type: intx
    value: '1000000'
  states: {}
- name: sym_sync_damping
  id: parameter
  parameters:
    label: Symbol Sync Damping Factor
    type: eng_float
    value: '1.0'
  states: {}
- name: sym_sync_loop_bw
  id: parameter
  parameters:
    label: Symbol Sync Loop BW
    type: eng_float
    value: '0.0045'
  states: {}

connections:
- [analog_agc_xx_0_0, '0', digital_symbol_sync_xx_1, '0']
- [analog_agc_xx_0_0, '0', dvbs2rx_rotator_cc_foffset_corr, '0']
- [analog_agc_xx_0_0, '0', pad_sink_2_0, '0']
- [blocks_null_source_0, '0', pad_sink_2, '0']
- [digital_costas_loop_cc_0, '0', dvbs2rx_plsync_cc_0_0, '0']
- [digital_symbol_sync_xx_1, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_1, '0', pad_sink_1, '0']
- [dvbs2rx_bbdeheader_bb_0, '0', pad_sink_0, '0']
- [dvbs2rx_bbdescrambler_bb_0, '0', dvbs2rx_bbdeheader_bb_0, '0']
- [dvbs2rx_bch_decoder_bb_0, '0', dvbs2rx_bbdescrambler_bb_0, '0']
- [dvbs2rx_ldpc_decoder_bb_0, '0', dvbs2rx_bch_decoder_bb_0, '0']
- [dvbs2rx_ldpc_decoder_bb_0, llr_pdu, dvbs2rx_xfecframe_demapper_cb_0, llr_pdu]
- [dvbs2rx_plsync_cc_0_0, '0', dvbs2rx_xfecframe_demapper_cb_0, '0']
- [dvbs2rx_plsync_cc_0_0, '0', pad_sink_1_0, '0']
- [dvbs2rx_plsync_cc_0_0, rotator_phase_inc, dvbs2rx_rotator_cc_foffset_corr, cmd]
- [dvbs2rx_rotator_cc_foffset_corr, '0', digital_symbol_sync_xx_1, '0']
- [dvbs2rx_rotator_cc_foffset_corr, '0', pad_sink_2, '0']
- [dvbs2rx_xfecframe_demapper_cb_0, '0', blocks_null_sink_0, '0']
- [dvbs2rx_xfecframe_demapper_cb_0, '0', dvbs2rx_ldpc_decoder_bb_0, '0']
- [pad_source_0, '0', analog_agc_xx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
