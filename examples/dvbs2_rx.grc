options:
  parameters:
    category: Custom
    description: Full DVB-S2 receiver. Processes IQ samples from stdin and outputs MPEG TS packets to stdout.
    generate_options: qt_gui
    id: dvbs2_rx
    output_language: python
    title: DVB-S2 Rx
  states: {}

blocks:
- name: Es
  id: variable
  parameters:
    value: '1'
  states: {}
- name: EsN0
  id: variable
  parameters:
    value: 10 ** (esn0_db / 10)
  states: {state: disabled}
- name: N0
  id: variable
  parameters:
    value: Es / EsN0
  states: {state: disabled}
- name: byte_rate
  id: variable
  parameters:
    value: bitrate / 8
  states: {state: disabled}
- name: code_rate
  id: variable
  parameters:
    value: modcod.upper().replace("8PSK", "").replace("QPSK", "")
  states: {}
- name: constellation
  id: variable
  parameters:
    value: modcod.replace(code_rate, "")
  states: {}
- name: freq
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@6
    label: Noise
    start: '0'
    step: '0.0001'
    stop: '0.2'
    value: snr
  states: {}
- name: pilot_len
  id: variable
  parameters:
    value: int((360-1)/16)*36
  states: {}
- name: plframe_len
  id: variable
  parameters:
    value: '33282'
  states: {}
- name: plheader_len
  id: variable
  parameters:
    value: '90'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: sym_rate * sps
  states: {}
- name: sym_sync_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@4
    label: LOOP_BW
    start: '0.0001'
    step: '0.0001'
    stop: '0.2'
    value: '0.065'
  states: {}
- name: agc_gain
  id: parameter
  parameters:
    label: AGC gain
    type: eng_float
    value: '1'
  states: {}
- name: agc_rate
  id: parameter
  parameters:
    label: AGC update rate
    type: eng_float
    value: '2e-5'
  states: {}
- name: agc_ref
  id: parameter
  parameters:
    label: AGC's reference value
    type: eng_float
    value: '1'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: bitrate
  id: parameter
  parameters:
    label: bit rate in bps
    short_id: b
    type: intx
    value: '10000000'
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/semikozov/code/radio/demod.ts
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/semikozov/code/radio/test/modulated.iq
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/semikozov/code/radio/records/SDRuno_20240603_165435Z_1199978kHz.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: debug
  id: parameter
  parameters:
    label: debugging level
    short_id: d
    type: intx
    value: '1'
  states: {}
- name: dvbs2rx_rx_hier_0
  id: dvbs2rx_rx_hier
  parameters:
    agc_gain: agc_gain
    agc_rate: agc_rate
    agc_ref: agc_ref
    debug: debug
    frame_size: frame_size
    gold_code: gold_code
    modcod: modcod
    pl_freq_est_period: pl_freq_est_period
    rolloff: rolloff
    rrc_delay: rrc_delay
    rrc_nfilts: rrc_nfilts
    sps: sps
    sym_rate: sym_rate
    sym_sync_damping: sym_sync_damping
    sym_sync_loop_bw: sym_sync_loop_bw
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nimport random\nimport collections\nimport struct\nimport itertools\nimport enum \nimport ctypes\n\nfrom itertools import cycle, islice\nfrom gnuradio import gr\n\nimport pmt\n\nclass UPID(enum.Enum):\n    TLM = np.byte(0x40)\n    DUMMY = np.byte(0x20)\n    \nSYM_RATE = 1000000 # mb used for tlm rate check\nSTRICT_CHUNK_SIZE = 4096\nFRAME_SIZE = 188\nSYNC = 0x47\nDUMMY_BYTE = np.byte(0xAA)\n\ndef consume(iterator, n):\n    \"Advance the iterator n-steps ahead. If n is none, consume entirely.\"\n    if n is None:\n        collections.deque(iterator, maxlen=0)\n    else:\n        next(islice(iterator, n, n), None)\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, fer_count=1000):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='FER',   # will show up in GRC\n            in_sig=[np.byte],\n            out_sig=[np.float32]\n        )\n        self.message_port_register_out(pmt.intern('fer_counter'))\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.measurements = fer_count\n        \n        self.fer: float = 0\n        self.byte_err_cnt = 0\n        self.frame_count = 0\n        self.fer_cnt = 0\n        self.i_fer_cnt = 0\n        self.least_dummy_cnt = 0\n        self.most_dummy_cnt = 0\n        self.tlm_cnt = 0\n        self.prev_frame_bytes = []\n    \n    def sync_find(self, chunk: np.ndarray) -> list:\n        frames = []\n        if len(self.prev_frame_bytes):\n            lost = FRAME_SIZE - self.prev_frame_bytes.size\n            prev_frame = np.append(self.prev_frame_bytes, chunk[:lost])\n            frames.append(prev_frame)\n            self.prev_frame_bytes = []\n            chunk = chunk[lost:]\n        it = iter(enumerate(chunk))\n        temp_err = 0\n        for index, byte in it:\n            if byte != 0x47: \n                self.byte_err_cnt += 1\n                temp_err = self.byte_err_cnt // FRAME_SIZE \n                continue \n            if chunk.size - index < FRAME_SIZE:\n                self.prev_frame_bytes = chunk[index:]\n                break\n            \n            frame = chunk[index:index + FRAME_SIZE]\n            frames.append(frame)    \n            consume(it, FRAME_SIZE - 1)\n            self.fer_cnt += temp_err\n            temp_err = 0\n            self.byte_err_cnt = 0\n        return frames\n    \n    def check_header(self, header: list) -> bool:\n        if header[2] == UPID.TLM.value:\n            return False\n        elif header[2] == UPID.DUMMY.value:\n            uk_field = header[3] & 0b11110000\n            least_dummy_cnt = int(header[3] & 0b00001111)\n            most_dummy_cnt = int.from_bytes(header[4:8].tobytes(), 'big', signed=True)\n            \n            b = self.check_least_dummy_counter(least_dummy_cnt) & \\\n                self.check_most_dummy_counter(most_dummy_cnt) & \\\n                uk_field.bit_count() == 1\n                \n            self.least_dummy_cnt = least_dummy_cnt\n            self.most_dummy_cnt = most_dummy_cnt\n            return b\n        else:\n            return False\n        \n    def check_correctness(self, frame: np.ndarray) -> None:\n        if self.frame_count >= self.measurements:\n            self.fer = self.fer_cnt / self.measurements\n            self.fer_cnt = 0\n            self.frame_count = 0\n        \n        b = self.check_header(frame[:8]) & self.check_payload(frame[8:].tolist())\n        if not b:\n            self.i_fer_cnt += 1\n            self.fer_cnt += 1\n        \n        self.frame_count += 1\n    \n    def check_least_dummy_counter(self, cnt: int) -> bool:\n        b = (cnt - self.least_dummy_cnt == -15) or (cnt - self.least_dummy_cnt == 1) \n        return b\n    \n    def check_most_dummy_counter(self, cnt: int) -> bool:\n        b = (cnt - self.most_dummy_cnt == 1) \n        return b\n    \n    def check_payload(self, payload: list, pid: UPID = UPID.DUMMY) -> bool:\n        if pid == UPID.DUMMY:\n            for byte in payload:\n                if byte != DUMMY_BYTE:\n                    return False\n            return True\n        else:\n            return True\n    \n    def work(self, input_items, output_items):\n        frames = self.sync_find(input_items[0])\n        for index, frame in enumerate(frames):\n            if frame[2] == UPID.TLM.value:\n                continue\n            self.check_correctness(frame)\n        output_items[0][:] = self.fer * 100\n        self.message_port_pub(pmt.intern('fer_counter'), pmt.intern(f'{self.i_fer_cnt}'))\n        return len(output_items[0])\n        \n"
    fer_count: '1000'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import random
      import collections
      import struct
      import itertools
      import enum 
      import ctypes
      import pmt

      from itertools import cycle, islice
      from gnuradio import gr

      from itertools import islice, cycle

      class UPID(enum.Enum):
          TLM = np.byte(0x40)
          DUMMY = 0x20
          
      SYM_RATE = 1000000 # mb used for tlm rate check
      STRICT_CHUNK_SIZE = 4096
      FRAME_SIZE = 188
      SYNC = 0x47
      DUMMY_BYTE_MASK = np.byte(0x55)

      textboxValue = ""

      def consume(iterator, n):
          "Advance the iterator n-steps ahead. If n is none, consume entirely."
          if n is None:
              collections.deque(iterator, maxlen=0)
          else:
              next(islice(iterator, n, n), None)

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, ber_count=1000):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='BER',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=[np.float32]
              )
              self.message_port_register_out(pmt.intern('ber_counter'))
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.measurements = ber_count
              self.ber: float = 0
              self.ber_cnt: int = 0
              self.i_ber_cnt: int = 0
              self.prev_frame_bytes = []
              self.frame_count = 0
              self.first = True
              self.least_dummy_cnt = 0
              self.most_dummy_cnt = 0
              self.tlm_cnt = 0
              self.counter = cycle([i for i in range(16, 32, 1)])
              
          def sync_find(self, chunk: np.ndarray) -> list:
              frames = []
              if len(self.prev_frame_bytes):
                  lost = FRAME_SIZE - len(self.prev_frame_bytes)
                  prev_frame = np.append(self.prev_frame_bytes, chunk[:lost])
                  frames.append(prev_frame)
                  self.prev_frame_bytes = []
                  chunk = chunk[lost:]
              it = iter(enumerate(chunk))
              for index, byte in it:
                  if byte != 0x47:
                      continue 
                  if chunk.size - index < FRAME_SIZE:
                      self.prev_frame_bytes = chunk[index:]
                      break
                  frame = chunk[index:index + FRAME_SIZE]
                  frames.append(frame)   
                  consume(it, FRAME_SIZE - 1)
              
              return frames
          
          def check_header(self, header: list) -> bool:
              if header[2] == UPID.TLM.value:
                  return False
              elif header[2] == UPID.DUMMY.value:
                  uk_field = header[3] & 0b11100000
                  self.ber_cnt += uk_field.bit_count()
                  
                  least_dummy_cnt = int(header[3] & 0b00001111)
                  most_dummy_cnt = int.from_bytes(header[4:8].tobytes(), 'big', signed=True)
                  
                  b = self.check_least_dummy_counter(least_dummy_cnt) & \
                      self.check_most_dummy_counter(most_dummy_cnt)
                      
                  self.least_dummy_cnt = least_dummy_cnt
                  self.most_dummy_cnt = most_dummy_cnt
                  return b
              else:
                  return False
          
          def check_correctness(self, frame: np.ndarray) -> None:
              if self.frame_count > self.measurements:
                  self.frame_count = 0
                  self.ber = self.ber_cnt / (self.measurements * FRAME_SIZE * 8) 
                  #print(f"Current BER = {self.ber}")  
                  self.ber_cnt = 0
              
              b = self.check_header(frame[:8]) & self.check_payload(frame[8:].tolist())

              self.frame_count += 1
          
          def check_least_dummy_counter(self, cnt: int):
              flag = (cnt - self.least_dummy_cnt == -15) or (cnt - self.least_dummy_cnt == 1)
              if not flag:
                  self.i_ber_cnt += cnt - self.least_dummy_cnt  
                  self.ber_cnt += cnt - self.least_dummy_cnt
              return flag
          
          def check_most_dummy_counter(self, cnt: int):
              flag = cnt - self.most_dummy_cnt == 1
              if not flag:
                  self.i_ber_cnt += 1
                  self.ber_cnt += 1
              return flag
          
          def check_payload(self, payload: list, pid: UPID = UPID.DUMMY):
              temp_cnt = 0
              for byte in payload:
                  masked = byte & DUMMY_BYTE_MASK
                  temp_cnt += masked.bit_count()
              self.ber_cnt += temp_cnt
              self.i_ber_cnt += temp_cnt 
              return temp_cnt == 0
          
          def work(self, input_items, output_items):
              global textboxValue
              frames = self.sync_find(input_items[0])
              for index, frame in enumerate(frames):
                  if frame[2] == UPID.TLM.value:
                      continue
                  self.check_correctness(frame)
              output_items[0][:] = self.ber * 100
              self.message_port_pub(pmt.intern('ber_counter'), pmt.intern(f'{self.i_ber_cnt}'))
              return len(output_items[0])
    ber_count: '1000'
  states: {}
- name: frame_size
  id: parameter
  parameters:
    label: FECFRAME size
    short_id: f
    type: str
    value: normal
  states: {}
- name: gold_code
  id: parameter
  parameters:
    label: Gold code
    type: intx
    value: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: modcod
  id: parameter
  parameters:
    label: MODCOD
    short_id: m
    type: str
    value: QPSK1/4
  states: {}
- name: pl_freq_est_period
  id: parameter
  parameters:
    label: PL synchronizer's frequency estimation period in frames
    type: intx
    value: '10'
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tabs@4
    legend: 'False'
    name: '"PL Sync Output"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tabs@2
    legend: 'False'
    name: '"Symbol Sync Output"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: tabs@7
    is_pair: 'False'
    label: Current bit errors
    type: string
  states: {}
- name: qtgui_edit_box_msg_1
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: tabs@7
    is_pair: 'False'
    label: Current frame errors
    type: string
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    gui_hint: tabs@5
    label1: Im
    label2: Re
    samp_per_symbol: '1'
    size: '1024'
    srate: samp_rate
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: tabs@1
    label1: Before
    label2: After
    name: '"Frequency Correction"'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: tabs@6
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: tabs@0:0,3,1,1
    name: '"RMS Level"'
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: tabs@7
    label1: FER
    label2: BER
    max: '100'
    min: '0'
    name: '"Packet error rate (%)"'
    nconnections: '2'
    type: float
    update_time: '0.001'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: tabs@3
    label1: I
    label2: Q
    size: plframe_len - pilot_len - plheader_len
    srate: sym_rate
    type: complex
    ylabel: PLFRAME Symbols
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@0:0,0,1,3
    name: '"Spectrogram"'
    type: complex
  states: {}
- name: rolloff
  id: parameter
  parameters:
    label: rolloff factor
    short_id: r
    type: eng_float
    value: '0.35'
  states: {}
- name: rrc_delay
  id: parameter
  parameters:
    label: RRC filter delay in symbol periods
    type: intx
    value: '25'
  states: {}
- name: rrc_nfilts
  id: parameter
  parameters:
    label: number of branches on the polyphase RRC filter
    type: intx
    value: '128'
  states: {}
- name: snr
  id: parameter
  parameters:
    label: starting SNR in dB
    type: eng_float
    value: '0'
  states: {}
- name: soapy_sdrplay_source_0
  id: soapy_sdrplay_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: sps
  id: parameter
  parameters:
    label: oversampling ratio in samples per symbol
    short_id: o
    type: eng_float
    value: '10'
  states: {}
- name: sym_rate
  id: parameter
  parameters:
    label: symbol rate in bauds
    short_id: s
    type: intx
    value: '1000000'
  states: {}
- name: sym_sync_damping
  id: parameter
  parameters:
    label: symbol synchronizer's damping factor
    type: eng_float
    value: '1.0'
  states: {}
- name: sym_sync_loop_bw
  id: parameter
  parameters:
    label: symbol synchronizer's loop bandwidth
    type: eng_float
    value: '0.0045'
  states: {state: disabled}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0
    label0: Input
    label1: Frequency Correction
    label2: Symbol Sync
    label3: Frame Recovery
    label4: Phase Recovery
    label5: Eye Diagrams
    label6: Noise/Signal
    label7: Error Rate
    num_tabs: '8'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: bytes
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: in_signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: bytes
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: in_signal
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0, '0', qtgui_freq_sink_x_1, '1']
- [blocks_add_xx_0, '0', dvbs2rx_rx_hier_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_rms_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_throttle2_0, '0', blocks_add_xx_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_1, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [dvbs2rx_rx_hier_0, '0', blocks_file_sink_0, '0']
- [dvbs2rx_rx_hier_0, '0', virtual_sink_0, '0']
- [dvbs2rx_rx_hier_0, '1', qtgui_const_sink_x_1_0, '0']
- [dvbs2rx_rx_hier_0, '2', qtgui_const_sink_x_1, '0']
- [dvbs2rx_rx_hier_0, '2', qtgui_eye_sink_x_0, '0']
- [dvbs2rx_rx_hier_0, '2', qtgui_time_sink_x_1, '0']
- [dvbs2rx_rx_hier_0, '3', qtgui_freq_sink_x_0, '1']
- [dvbs2rx_rx_hier_0, '4', qtgui_freq_sink_x_0, '0']
- [epy_block_0, '0', qtgui_number_sink_1, '0']
- [epy_block_0, fer_counter, qtgui_edit_box_msg_1, val]
- [epy_block_1, '0', qtgui_number_sink_1, '1']
- [epy_block_1, ber_counter, qtgui_edit_box_msg_0, val]
- [soapy_sdrplay_source_0, '0', blocks_throttle2_0, '0']
- [virtual_source_0, '0', epy_block_0, '0']
- [virtual_source_0, '0', epy_block_1, '0']
- [virtual_source_1, '0', blocks_file_sink_1, '0']
- [virtual_source_1, '0', blocks_rms_xx_0, '0']
- [virtual_source_1, '0', qtgui_freq_sink_x_1, '0']
- [virtual_source_1, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
